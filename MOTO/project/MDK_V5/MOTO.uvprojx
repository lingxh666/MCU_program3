# Keil uVision project MOTO.uvprojx, settings and files
target MOTO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F421F8P7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.8
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: MOTO +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F421F8P7, USE_STDPERIPH_DRIVER, AT_START_F421_V1
  c misc: --no-multibyte-chars
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: at32f421_int.c at32f421_wk_config.c main.c wk_system.c stepper_motor.c modbus_rtu.c motor_monitor.c
  group firmware
    ../../libraries/drivers/src/: at32f421_adc.c at32f421_crc.c at32f421_crm.c at32f421_debug.c at32f421_dma.c at32f421_flash.c at32f421_gpio.c at32f421_misc.c at32f421_pwc.c at32f421_scfg.c at32f421_tmr.c at32f421_usart.c at32f421_wdt.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f421.c
    ./: startup_at32f421.s
