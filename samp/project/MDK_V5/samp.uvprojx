# Keil uVision project samp.uvprojx, settings and files
target samp (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F435VGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.4
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: samp +hex
  AfterMake: C:\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe  --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F435VGT7, USE_STDPERIPH_DRIVER, ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, ARM_MATH_LOOPUNROLL
  c misc: --no-multibyte-chars
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;../../middlewares/usb_drivers/inc;../../libraries/cmsis/dsp/include;../../libraries/cmsis/dsp/PrivateInclude;../../middlewares/freertos/source/include;../../middlewares/freertos/source/portable/memmang;../../middlewares/freertos/source/portable/rvds/ARM_CM4F;../../middlewares/bsp;../../middlewares/bsp/fal;../../middlewares/bsp/flashDB;../../middlewares/usbh_class/usbh_msc;../../middlewares/3rd_party/fatfs/source
  memory RVCT4: ROM 0x8000000 size 0x3f000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_int.c at32f435_437_wk_config.c main.c wk_system.c usb_app.c usbh_user.c freertos_app.c include_port.c
  group firmware
    ../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_tmr.c at32f435_437_ertc.c at32f435_437_gpio.c at32f435_437_usart.c at32f435_437_pwc.c at32f435_437_adc.c at32f435_437_dma.c at32f435_437_debug.c at32f435_437_flash.c at32f435_437_crc.c at32f435_437_wdt.c at32f435_437_exint.c at32f435_437_misc.c at32f435_437_scfg.c at32f435_437_usb.c at32f435_437_acc.c at32f435_437_can.c at32f435_437_qspi.c
  group cmsis
    ./: startup_at32f435_437.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
  group middlewares/usb_driver
    ../../middlewares/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c usbh_core.c usbh_int.c usbh_ctrl.c
  group cmsis_dsp
    ../../libraries/cmsis/dsp/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../libraries/cmsis/dsp/Source/BayesFunctions/: BayesFunctions.c
    ../../libraries/cmsis/dsp/Source/CommonTables/: CommonTables.c
    ../../libraries/cmsis/dsp/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../libraries/cmsis/dsp/Source/ControllerFunctions/: ControllerFunctions.c
    ../../libraries/cmsis/dsp/Source/DistanceFunctions/: DistanceFunctions.c
    ../../libraries/cmsis/dsp/Source/FastMathFunctions/: FastMathFunctions.c
    ../../libraries/cmsis/dsp/Source/FilteringFunctions/: FilteringFunctions.c
    ../../libraries/cmsis/dsp/Source/InterpolationFunctions/: InterpolationFunctions.c
    ../../libraries/cmsis/dsp/Source/MatrixFunctions/: MatrixFunctions.c
    ../../libraries/cmsis/dsp/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../../libraries/cmsis/dsp/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../../libraries/cmsis/dsp/Source/SupportFunctions/: SupportFunctions.c
    ../../libraries/cmsis/dsp/Source/SVMFunctions/: SVMFunctions.c
    ../../libraries/cmsis/dsp/Source/TransformFunctions/: TransformFunctions.c
  group usbd_class
    ../src/: cdc_class.c cdc_desc.c
  group usbh_class
    ../../middlewares/usbh_class/usbh_msc/: usbh_msc_class.c usbh_msc_bot_scsi.c
    ../src/: usbh_msc_diskio.c
  group middlewares/fatfs
    ../../middlewares/3rd_party/fatfs/source/: ff.c ffsystem.c ffunicode.c
  group middlewares/freertos
    ../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
    ../../middlewares/freertos/source/portable/memmang/: heap_4.c
  group middlewares/bsp
    ../../middlewares/bsp/: bsp_io.c bsp_adc.c bsp_qspi_flash.c bsp_rtc.c bsp_wdt.c bsp_crc.c bsp_uart.c bsp_uart_collector.c bsp_uart_bluetooth.c bsp_screen.c bsp_uart_xian.c bsp_uart_4g.c bsp_uart_spare.c bsp_uart_admodule.c bsp_can_motor.c bsp_wiegand.c bsp_pvm.c app_config.c app_sampling.c app_screen.c app_modbus.c
  group middlewares/fal
    ../../middlewares/bsp/fal/: fal.c fal_flash.c fal_partition.c fal_flash_AT32_port.c fal_flash_qspi_port.c
  group middlewares/flashDB
    ../../middlewares/bsp/flashDB/: fdb.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c app_flashdb.c
