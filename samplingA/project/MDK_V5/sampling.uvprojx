# Keil uVision project sampling.uvprojx, settings and files
target sampling (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.2
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sampling +hex
  AfterMake: C:\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe  --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c misc: --no-multibyte-chars
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;../../middlewares/freertos/source/include;../../middlewares/freertos/source/portable/memmang;../../middlewares/freertos/source/portable/rvds/ARM_CM4F;..\..\middlewares\bsp;..\..\middlewares\bsp\fal;..\..\middlewares\bsp\flashDB;..\..\middlewares\bsp\freemodbus
  memory RVCT4: ROM 0x8002000 size 0x3f000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: main.c at32f403a_407_wk_config.c at32f403a_407_int.c wk_system.c freertos_app.c include_port.c rtc.c
  group firmware
    ../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_tmr.c at32f403a_407_rtc.c at32f403a_407_gpio.c at32f403a_407_usart.c at32f403a_407_pwc.c at32f403a_407_adc.c at32f403a_407_spi.c at32f403a_407_dma.c at32f403a_407_flash.c at32f403a_407_crc.c at32f403a_407_wdt.c at32f403a_407_exint.c at32f403a_407_misc.c at32f403a_407_debug.c at32f403a_407_bpr.c
  group cmsis
    ./: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group middlewares/freertos
    ../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
    ../../middlewares/freertos/source/portable/memmang/: heap_4.c
  group bsp
    ../../middlewares/bsp/: bsp_button.c flash.c multi_button.c retain_judge.c screen.c spi_flash.c wiegand.c work.c sampling.c Commtrigger.c Flowtrigger.c Switchtrigger.c Timetrigger.c sampling_time.c ota.c screen_cache.c record_cache.c sample_id.c lbs_location.c
  group fal
    ../../middlewares/bsp/fal/: fal.c fal_flash.c fal_flash_AT32_port.c fal_flash_spi_nor_port.c fal_partition.c
  group flashDB
    ../../middlewares/bsp/flashDB/: fdb.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c app_flashdb.c
  group freemodbus
    ../../middlewares/bsp/freemodbus/: mb.c mb_reg_dayue.c mb_reg_dahu.c mb_reg_sichuan.c mb_reg_xian.c
