# Keil uVision project MOTRO4.uvprojx, settings and files
target MOTRO4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F422CBT7 ArteryTek
  pack: ArteryTek.AT32F422_426_DFP.2.0.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MOTRO4 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F422CBT7, USE_STDPERIPH_DRIVER, AT_START_F422_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../src/: at32f422_426_int.c at32f422_426_wk_config.c main.c wk_system.c stepper_motor.c motor_monitor.c can_protocol.c
  group firmware
    ../../libraries/drivers/src/: at32f422_426_crm.c at32f422_426_tmr.c at32f422_426_gpio.c at32f422_426_usart.c at32f422_426_pwc.c at32f422_426_adc.c at32f422_426_can.c at32f422_426_dma.c at32f422_426_debug.c at32f422_426_flash.c at32f422_426_wdt.c at32f422_426_misc.c at32f422_426_scfg.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f422_426.c
    ./: startup_at32f422_426.s
